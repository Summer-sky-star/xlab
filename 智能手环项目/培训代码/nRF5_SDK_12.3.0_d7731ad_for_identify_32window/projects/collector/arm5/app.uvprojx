# Keil uVision project app.uvprojx, settings and files
target nrf51822_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 DEBUG RADIOLAND
  c include: ..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_dtm;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\components\ble\ble_services\ble_bas;..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\components\ble\ble_services\ble_cscs;..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\components\ble\ble_services\ble_dfu;..\..\..\components\ble\ble_services\ble_dis;..\..\..\components\ble\ble_services\ble_gls;..\..\..\components\ble\ble_services\ble_hids;..\..\..\components\ble\ble_services\ble_hrs;..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\components\ble\ble_services\ble_hts;..\..\..\components\ble\ble_services\ble_ias;..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\components\ble\ble_services\ble_lbs;..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\components\ble\ble_services\ble_lls;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\components\ble\ble_services\ble_rscs;..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\components\ble\ble_services\ble_tps;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\drivers_nrf\adc;..\..\..\components\drivers_nrf\clock;..\..\..\components\drivers_nrf\common;..\..\..\components\drivers_nrf\comp;..\..\..\components\drivers_nrf\delay;..\..\..\components\drivers_nrf\gpiote;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\i2s;..\..\..\components\drivers_nrf\lpcomp;..\..\..\components\drivers_nrf\pdm;..\..\..\components\drivers_nrf\power;..\..\..\components\drivers_nrf\ppi;..\..\..\components\drivers_nrf\pwm;..\..\..\components\drivers_nrf\qdec;..\..\..\components\drivers_nrf\rng;..\..\..\components\drivers_nrf\rtc;..\..\..\components\drivers_nrf\saadc;..\..\..\components\drivers_nrf\spi_master;..\..\..\components\drivers_nrf\spi_slave;..\..\..\components\drivers_nrf\swi;..\..\..\components\drivers_nrf\timer;..\..\..\components\drivers_nrf\twi_master;..\..\..\components\drivers_nrf\twis_slave;..\..\..\components\drivers_nrf\uart;..\..\..\components\drivers_nrf\usbd;..\..\..\components\drivers_nrf\wdt;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\fds;..\..\..\components\libraries\fifo;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\pwm;..\..\..\components\libraries\queue;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\slip;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi;..\..\..\components\libraries\uart;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\usbd\config;..\..\..\components\libraries\util;..\..\..\components\softdevice\common\softdevice_handler;..\..\..\components\softdevice\s130\headers;..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\components\toolchain;..\..\..\external\segger_rtt;.\
  asm define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51422,-DBOARD_PCA10028,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DNRF51,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_dtm;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\components\ble\ble_services\ble_bas;..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\components\ble\ble_services\ble_cscs;..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\components\ble\ble_services\ble_dfu;..\..\..\components\ble\ble_services\ble_dis;..\..\..\components\ble\ble_services\ble_gls;..\..\..\components\ble\ble_services\ble_hids;..\..\..\components\ble\ble_services\ble_hrs;..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\components\ble\ble_services\ble_hts;..\..\..\components\ble\ble_services\ble_ias;..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\components\ble\ble_services\ble_lbs;..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\components\ble\ble_services\ble_lls;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\components\ble\ble_services\ble_rscs;..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\components\ble\ble_services\ble_tps;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\drivers_nrf\adc;..\..\..\components\drivers_nrf\clock;..\..\..\components\drivers_nrf\common;..\..\..\components\drivers_nrf\comp;..\..\..\components\drivers_nrf\delay;..\..\..\components\drivers_nrf\gpiote;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\i2s;..\..\..\components\drivers_nrf\lpcomp;..\..\..\components\drivers_nrf\pdm;..\..\..\components\drivers_nrf\power;..\..\..\components\drivers_nrf\ppi;..\..\..\components\drivers_nrf\pwm;..\..\..\components\drivers_nrf\qdec;..\..\..\components\drivers_nrf\rng;..\..\..\components\drivers_nrf\rtc;..\..\..\components\drivers_nrf\saadc;..\..\..\components\drivers_nrf\spi_master;..\..\..\components\drivers_nrf\spi_slave;..\..\..\components\drivers_nrf\swi;..\..\..\components\drivers_nrf\timer;..\..\..\components\drivers_nrf\twi_master;..\..\..\components\drivers_nrf\twis_slave;..\..\..\components\drivers_nrf\uart;..\..\..\components\drivers_nrf\usbd;..\..\..\components\drivers_nrf\wdt;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\fds;..\..\..\components\libraries\fifo;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\pwm;..\..\..\components\libraries\queue;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\slip;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi;..\..\..\components\libraries\uart;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\usbd\config;..\..\..\components\libraries\util;..\..\..\components\softdevice\common\softdevice_handler;..\..\..\components\softdevice\s130\headers;..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\components\toolchain;..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
  group Application
    ./: sdk_config.h
    ../: main.c kx022.c queue.c sht3.c battery.c flash.c rtc.c record_humiture.c nrf_drv_spi_nrf51.c config.c
  group nRF_BLE
    ../../../components/ble/common/: ble_advdata.c ble_srv_common.c
    ../../../components/ble/ble_advertising/: ble_advertising.c
  group nRF_BLE_Services
    ../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../components/drivers_nrf/adc/: nrf_drv_adc.c
  group nRF_Libraries
    ../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../components/libraries/fifo/: app_fifo.c
    ../../../components/libraries/fstorage/: fstorage.c
    ../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../components/libraries/twi/: app_twi.c
    ../../../components/libraries/queue/: nrf_queue.c
    ../../../components/libraries/crc32/: crc32.c
  group nRF_SoftDevice
    ../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_Log
    ../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
